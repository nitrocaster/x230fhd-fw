# IAR project x230fhd.ewp, settings and files
configuration STM8S208 (STM8, debug)
  General.GenDeviceSelectMenu: STM8S208MB STM8S208MB
  General.GenCodeModel: 1
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: USE_STM8_128_EVAL; STM8S208
  ICCSTM8.CCIncludePath2: $PROJ_DIR$; E:\dev\stm8\Libraries\STM8S_StdPeriph_Driver\inc; E:\dev\stm8\Utilities\STM8S_EVAL; E:\dev\stm8\Utilities\STM8S_EVAL\STM8S-128_EVAL; E:\dev\stm8\Utilities\STM8S_EVAL\Common
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration STM8S207 (STM8, debug)
  as the first configuration, except:
  General.GenDeviceSelectMenu: STM8S207MB STM8S207MB
  ICCSTM8.CCDefines: USE_STM8_128_EVAL; STM8S207
configuration STM8S105 (STM8, debug)
  as the first configuration, except:
  General.GenDeviceSelectMenu: STM8S105C6 STM8S105C6
  ICCSTM8.CCDefines: STM8S105
  ICCSTM8.CCIncludePath2: $PROJ_DIR$; E:\dev\stm8\Libraries\STM8S_StdPeriph_Driver\inc
configuration STM8S103 (STM8, debug)
  as the first configuration, except:
  General.GenDeviceSelectMenu: STM8S003F3 STM8S003F3
  General.GenCodeModel: 0
  General.GenDataModel: 0
  ICCSTM8.CCDefines: STM8S003
  ICCSTM8.CCIncludePath2: $PROJ_DIR$; E:\dev\stm8\Libraries\STM8S_StdPeriph_Driver\inc
  OBJCOPY.OOCOutputFile: x230fhd.srec
  ILINK.IlinkOutputFile: x230fhd.out
configuration STM8S903 (STM8, debug)
  as the first configuration, except:
  General.GenDeviceSelectMenu: STM8S903K3 STM8S903K3
  ICCSTM8.CCDefines: STM8S903
  ICCSTM8.CCIncludePath2: $PROJ_DIR$; E:\dev\stm8\Libraries\STM8S_StdPeriph_Driver\inc
configuration STM8AF52Ax (STM8, debug)
  as the first configuration, except:
  General.GenDeviceSelectMenu: STM8AF52AA STM8AF52AA
  ICCSTM8.CCDefines: USE_STM8_128_EVAL; STM8AF52Ax
configuration STM8AF62Ax (STM8, debug)
  as the first configuration, except:
  General.GenDeviceSelectMenu: STM8AF62AA STM8AF62AA
  ICCSTM8.CCDefines: USE_STM8_128_EVAL; STM8AF62Ax
configuration STM8AF626x (STM8, debug)
  as the first configuration, except:
  General.GenDeviceSelectMenu: STM8AF6269 STM8AF6269
  ICCSTM8.CCDefines: STM8AF626x
  ICCSTM8.CCIncludePath2: $PROJ_DIR$; E:\dev\stm8\Libraries\STM8S_StdPeriph_Driver\inc
configuration STM8AF622x (STM8, debug)
  as the first configuration, except:
  General.GenDeviceSelectMenu: STM8AF6226 STM8AF6226
  ICCSTM8.CCDefines: STM8AF622x
  ICCSTM8.CCIncludePath2: $PROJ_DIR$; E:\dev\stm8\Libraries\STM8S_StdPeriph_Driver\inc
  group StdPeriph_Drivers
    ../../dev/stm8/Libraries/STM8S_StdPeriph_Driver/src/: stm8s_adc1.c stm8s_adc2.c stm8s_awu.c stm8s_beep.c stm8s_can.c stm8s_clk.c stm8s_exti.c stm8s_flash.c stm8s_gpio.c stm8s_i2c.c stm8s_itc.c stm8s_iwdg.c stm8s_rst.c stm8s_spi.c stm8s_tim1.c stm8s_tim2.c stm8s_tim3.c stm8s_tim4.c stm8s_tim5.c stm8s_tim6.c stm8s_uart1.c stm8s_uart2.c stm8s_uart3.c stm8s_uart4.c stm8s_wwdg.c
  group STM8S_EVAL
    ../../dev/stm8/Utilities/STM8S_EVAL/: stm8s_eval.c
  group User
    ./: common.h main.c stm8s_conf.h stm8s_it.c stm8s_it.h
